<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\task3.s43.ewp</path>
  </project>
  <batchBuild/>
</workspace>


